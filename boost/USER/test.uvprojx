# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.0-Beta4
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\USER
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: startup_stm32f10x_ld.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
